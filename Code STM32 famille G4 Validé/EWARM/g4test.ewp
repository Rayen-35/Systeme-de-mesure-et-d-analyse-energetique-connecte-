# IAR project g4test.ewp, settings and files
configuration g4test (ARM, debug)
  General.OGChipSelectEditMenu: STM32G431RB ST STM32G431RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G431xx; SPI_XFER_STPM3X
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G4xx/Include; ../Drivers/CMSIS/Include; C:\Users\BAZINFO\Desktop\g4test - lm3allim\Metrology\tasks\inc; C:\Users\BAZINFO\Desktop\g4test - lm3allim\Metrology\tasks\src; C:\Users\BAZINFO\Desktop\g4test - lm3allim\Metrology\include\inc; C:\Users\BAZINFO\Desktop\g4test - lm3allim\Metrology\drivers\src; C:\Users\BAZINFO\Desktop\g4test - lm3allim\Metrology\drivers\inc; C:\Users\BAZINFO\Desktop\g4test - lm3allim; C:\Users\BAZINFO\Desktop\g4test - lm3allim\EWARM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: g4test.hex
  ILINK.IlinkOutputFile: g4test.out
  ILINK.IlinkIcfFile: stm32g431xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Metrology/Drivers
    ../../STSW-STPM002 -  f1/Metrology/drivers/src/: metrology.c metrology_hal.c
  group Metrology/Include
    ../../STSW-STPM002 -  f1/Metrology/drivers/inc/: metrology_hal.h stpm_metrology.h
    ../../STSW-STPM002 -  f1/Metrology/tasks/inc/: metroTask.h
    ../../STSW-STPM002 -  f1/Metrology/include/inc/: st_device.h
  group Metrology/Tasks
    ../../STSW-STPM002 -  f1/Metrology/tasks/src/: metroTask.c
